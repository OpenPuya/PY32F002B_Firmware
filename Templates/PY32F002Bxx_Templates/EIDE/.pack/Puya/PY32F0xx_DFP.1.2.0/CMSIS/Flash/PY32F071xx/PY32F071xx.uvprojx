# Keil uVision project PY32F071xx.uvprojx, settings and files
target PY32F071xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F071xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F071x6
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY32F071xx_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: as above
  output: PY32F071xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F071x8
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F071xx_96 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: as above
  output: PY32F071xx_96
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F071x9
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F071xx_128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F071xx_128 +hex
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F071xB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OPT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x3 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: as above
  output: PY32F071xx_OPT
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: PY32F071xx_OPT,PY32F071xB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
