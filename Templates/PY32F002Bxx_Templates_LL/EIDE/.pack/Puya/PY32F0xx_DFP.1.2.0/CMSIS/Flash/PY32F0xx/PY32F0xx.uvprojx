# Keil uVision project PY32F0xx.uvprojx, settings and files
target PY32F0xx_8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: PY32F0xx_8
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_8
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY32F0xx_16 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_16
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F0xx_20 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_20
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_20
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F0xx_24 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_24
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_24
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F0xx_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_32
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F0xx_48 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_48
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_48
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY32F0xx_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM PY32F0xx_64
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OPT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: PY32F0xx_OPT
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_OPT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
