# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F002Bxx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\..\..\..\Drivers\PY32F002B_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
    ../Src/: system_py32f002b.c
  group Application/User
    ../Src/: main.c py32f002b_hal_msp.c py32f002b_it.c
  group BSP/py32f002bxx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_Start_Kit.c
  group Drivers/PY32F002B_HAL_Driver
    ../../../../../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_uart.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
