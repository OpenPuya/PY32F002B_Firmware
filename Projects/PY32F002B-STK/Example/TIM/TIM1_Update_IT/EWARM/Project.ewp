# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F002Bx5 Puya PY32F002Bx5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F002Bx5
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32F002Bxx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32F002B_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f002bx5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32F002Bxx_Start_Kit
    ../../../../../../Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f002b.c
  group Drivers/PY32F002B_HAL_Driver
    ../../../../../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_uart.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c
  group Example/EWARM
    ./: startup_py32f002bxx.s
  group Example/User
    ../Src/: main.c py32f002b_hal_msp.c py32f002b_it.c
